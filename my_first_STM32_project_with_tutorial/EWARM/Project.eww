<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\my_first_STM32_project_with_tutorial.ewp</path>
  </project>
  <batchBuild />
</workspace>
